# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\User_Application\inc;..\Standard_Libraries\CMSIS\CM3\CoreSupport;..\Standard_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Standard_Libraries\STM32F10x_StdPeriph_Driver\inc;..\User_Libraries\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User_Application
    ../User_Application/src/: main.c stm32f10x_it.c
  group CMSIS
    ../Standard_Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Standard_Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Standard_Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Standard_Lib
    ../Standard_Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_tim.c
  group User_Lib
    ../User_Libraries/src/: my_usart.c DHT11.c DS18B20.c LCD_I2C.c my_i2c.c my_timer.c
  group FreeRTOS
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
